# Keil uVision project LiteOS_M_Core.uvprojx, settings and files
target CH32F208 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CH32F207VC WCH
  pack: Keil.WCH32F2xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CH32F20x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\SRC\StdPeriphDriver\inc;..\..\SRC\CMSIS;..\..\SRC\Debug;..\LiteOS_M_Core;.\liteos_m\components\backtrace;.\liteos_m\components\cpup;.\liteos_m\kernel\src;.\liteos_m\kernel\src\mm;.\liteos_m\kernel\include;.\liteos_m\kernel\arch\arm\cortex-m3\keil;.\liteos_m\kernel\arch\include;.\liteos_m\utils;.\liteos_m\utils\internal;.\liteos_m\third_party\bounds_checking_function\include;.\liteos_m\third_party\bounds_checking_function\src;.\liteos_m\components\exchook;.\liteos_m\components\power
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: ch32f20x_it.c Main.c system_ch32f20x.c
  group startup
    ../../SRC/Startup/: startup_ch32f20x_D8C.s
  group core
    ../../SRC/CMSIS/: core_cm3.c
  group debug
    ../../SRC/Debug/: debug.c
  group peripheral
    ../../SRC/StdPeriphDriver/src/: ch32f20x_adc.c ch32f20x_bkp.c ch32f20x_can.c ch32f20x_crc.c ch32f20x_dac.c ch32f20x_dbgmcu.c ch32f20x_dma.c ch32f20x_dvp.c ch32f20x_exti.c ch32f20x_flash.c ch32f20x_fsmc.c ch32f20x_gpio.c ch32f20x_i2c.c ch32f20x_iwdg.c ch32f20x_misc.c ch32f20x_opa.c ch32f20x_pwr.c ch32f20x_rcc.c ch32f20x_rng.c ch32f20x_rtc.c ch32f20x_sdio.c ch32f20x_spi.c ch32f20x_tim.c ch32f20x_usart.c ch32f20x_wwdg.c
  group LiteOS/components
    ./liteos_m/components/backtrace/: los_backtrace.c
    ./liteos_m/components/cpup/: los_cpup.c
    ./liteos_m/components/exchook/: los_exc_info.c los_exchook.c
    ./liteos_m/components/power/: los_pm.c
  group LiteOS/kernel
    ./liteos_m/kernel/src/: los_event.c los_init.c los_mux.c los_queue.c los_sched.c los_sem.c los_sortlink.c los_swtmr.c los_task.c los_tick.c
    ./liteos_m/kernel/src/mm/: los_membox.c los_memory.c
  group LiteOS/arch
    ./liteos_m/kernel/arch/arm/cortex-m3/keil/: los_arch_atomic.h los_arch_context.h los_arch_interrupt.h los_arch_timer.h los_context.c los_dispatch.S los_exc.S los_interrupt.c los_startup.s los_timer.c
  group LiteOS/utils
    ./liteos_m/utils/: los_debug.c los_error.c los_hook.c
  group LiteOS/third_party
    ./liteos_m/third_party/bounds_checking_function/src/: memcpy_s.c memmove_s.c memset_s.c strcpy_s.c strncpy_s.c
